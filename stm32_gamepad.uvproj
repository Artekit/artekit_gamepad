# Keil uVision project stm32_gamepad.uvproj, settings and files
target ak-stm32-lkit (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_gamepad
  c flags: Optim=4 OneElfS=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: .\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\STM32F10x_StdPeriph_Driver\inc;.\STM32_USB-FS-Device_Driver\inc;..\artekit_gamepad
  memory RVCT4: ROM 0x8000000 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group source
    ./: main.c stm32f10x_it.c stm32f10x_it.h startup_stm32f10x_md.s i2c.c i2c.h wii_cc.c wii_cc.h sys.c
  group st
    ./CMSIS/CM3/CoreSupport/: core_cm3.h core_cm3.c
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_tim.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_i2c.c
  group st_usb
    ./STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group user_usb
    ./: hw_config.h usb_conf.h usb_desc.c usb_desc.h usb_istr.c usb_istr.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h usb.c
